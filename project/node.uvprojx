# Keil uVision project node.uvprojx, settings and files
target node (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: node +hex
  AfterMake: fromelf.exe --bin -o./Obj/dtu.bin ./Obj/sx_demo.axf
  AfterMake: fromelf.exe --i32 -o./Obj/dtu.hex ./Obj/sx_demo.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER USE_BAND_433
  c include: ..\MCU\CM3;..\MCU\FWlib\inc;..\app;..\bsp;..\driver;..\radio;..\mac;..\system\crypto;..\radio\sx1276;..\MCU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ASM
    ../startup/: startup_stm32f10x_hd.s
  group app
    ../app/: main.c common.c timer.c
  group bsp
    ../bsp/: bsp.c sx1276-board.c
  group driver
    ../driver/: i2c.c uart.c spi.c systick.c rf.c
  group MCU
    ../MCU/: utilities.c
  group MCU\CM3
    ../MCU/CM3/: core_cm3.c system_stm32f10x.c stm32f10x.h
  group MCU\FWLIB
    ../MCU/FWlib/SRC/: stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c misc.c stm32f10x_rcc.c
  group radio
    ../radio/sx1276/: sx1276.c
  group mac
    ../mac/: LoRaMac.c LoRaMacCrypto.c
  group system\crypto
    ../system/crypto/: aes.c cmac.c
